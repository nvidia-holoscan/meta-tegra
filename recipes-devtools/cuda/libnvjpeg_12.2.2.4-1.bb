require cuda-shared-binaries.inc

MAINSUM = "bdd8afa77ed475733e0ada2d8fe8356615121b8610391a044272c79b35fed835"
MAINSUM:x86-64 = "5fe01f87567770d15b3f22dee1acfe575a147d8fcbc9b7e3bc8c5e8337d78f33"
DEVSUM = "16a6e183516f011db9f0a0eff056bef8c7ca688ee074f53424c652b6f79c3cb6"
DEVSUM:x86-64 = "2db9c1d0ad96aab955f81ac43a0649bd31af030e4c056d3722d7f212f367c17f"

BBCLASSEXTEND = "native nativesdk"
